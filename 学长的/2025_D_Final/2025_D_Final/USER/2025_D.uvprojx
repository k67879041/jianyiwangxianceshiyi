# Keil uVision project 2025_D.uvprojx, settings and files
target 2025_D (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: OLED +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_TABLE_SIN_F32,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\OLED;..\FWLIB\inc;..\HARDWARE\LED_KEY;..\HARDWARE\AD5933;..\DSP_LIB\Include;..\DSP_LIB;..\SOFTWARE;..\DSP\PrivateInclude;..\DSP\Source\BasicMathFunctions;..\DSP\Source\FastMathFunctions;..\DSP\Include;..\HARDWARE\RELAY;..\HARDWARE\AD9959;..\HARDWARE\EEPROM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c oledfont.h
    ../HARDWARE/LED_KEY/: key.c led.c
    ../HARDWARE/AD5933/: AD5933.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/AD9959/: AD9959.c AD9959_Outset.c
    ../HARDWARE/EEPROM/: 24cxx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_dma2d.c
  group README
    ../: readme.txt
  group DSP
    ../DSP_LIB/: arm_cortexM4lf_math.lib
    ../DSP/Include/: arm_common_tables.h arm_mve_tables.h arm_math.h
  group SOFTWARE
    ../SOFTWARE/: interrupt.c adc.c
